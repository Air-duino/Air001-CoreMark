# Keil uVision project CoreMark.uvprojx, settings and files
target Project (6190000::V6.19::ARMCLANG)
  device: AIR001Dev Generic
  pack: Keil.AIR001_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CoreMark
  c flags: Optim=5 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,AIR001_DEV,CORE_DEBUG=0
  c include: ..\inc;..\AIR001xx_HAL_Driver\Inc;..\AIR001xx_HAL_Driver\Inc\Legacy;..\CoreMark;..\CoreMark\simple
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/User
    ../src/: main.c air001xx_hal_msp.c air001xx_it.c
  group Drivers/AIR001xx_HAL_Driver
    ../AIR001xx_HAL_Driver/Src/: air001xx_hal.c air001xx_hal_cortex.c air001xx_hal_crc.c air001xx_hal_crc_ex.c air001xx_hal_gpio.c air001xx_hal_flash.c air001xx_hal_pwr.c air001xx_hal_pwr_ex.c air001xx_hal_rcc.c air001xx_hal_rcc_ex.c air001xx_hal_uart.c air001xx_hal_tim.c air001xx_hal_tim_ex.c air001xx_hal_dma.c
  group CoreMark
    ../CoreMark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
    ../CoreMark/simple/: ee_printf.c core_portme.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0

# Keil uVision project CoreMark.uvprojx, settings and files
target Project (6210000::V6.21::ARMCLANG)
  device: AIR001Dev Generic
  pack: AirM2M.AIR001_DFP.1.1.3
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CoreMark
  c flags: Optim=4 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,AIR001_DEV,CORE_DEBUG=0
  c include: ..\inc;..\Drivers\AIR001xx_HAL_Driver\Inc;..\CoreMark;..\CoreMark\simple
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/User
    ../src/: main.c air001xx_hal_msp.c air001xx_it.c
  group Drivers/AIR001xx_HAL_Driver
    ../Drivers/AIR001xx_HAL_Driver/Src/: air001xx_hal.c air001xx_hal_cortex.c air001xx_hal_flash.c air001xx_hal_gpio.c air001xx_hal_rcc.c air001xx_hal_rcc_ex.c air001xx_hal_tim.c air001xx_hal_tim_ex.c air001xx_hal_uart.c air001xx_hal_usart.c air001xx_hal_dma.c air001xx_hal_pwr.c air001xx_hal_pwr_ex.c
  group CoreMark
    ../CoreMark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
    ../CoreMark/simple/: ee_printf.c core_portme.c
software components: CMSIS:CORE 5.6.0, Device:Startup 0.0.1
